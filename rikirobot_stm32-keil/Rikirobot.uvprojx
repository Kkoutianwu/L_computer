# Keil uVision project Rikirobot.uvprojx, settings and files
target rikirobot (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: robot +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --gnu
  c include: .\Bsp;.\Driver;.\Stm32Libs\STM32F10x_StdPeriph_Driver\inc;.\Stm32Libs\STM32F10x_StdPeriph_Driver;.\Stm32Libs\CMSIS\CM3\CoreSupport;.\RosLibs;.\Driver\Battery;.\Driver\Encoder;.\Driver\Key;.\Driver\Kinematics;.\Driver\LED;.\Driver\OLED;.\Driver\PID;.\Driver\servo;.\Driver\sonar;.\Driver\timer;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\Driver\US_100;.\Driver\gy85;.\Driver\motor;.\User;.\Driver\Sports_Set
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/: main.cpp
  group Library
    ./Stm32Libs/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Driver
    ./Driver/Battery/: battery.cpp
    ./Driver/Key/: key.c
    ./Driver/LED/: led.cpp
    ./Driver/OLED/: oled.c
    ./Driver/PID/: PID.cpp
    ./Driver/servo/: servo.cpp
    ./Driver/sonar/: sonar.c
    ./Driver/timer/: timer.c
    ./Driver/US_100/: US_100.cpp
    ./Driver/gy85/: gy85.cpp
    ./Driver/Encoder/: encoder.c
  group Bsp
    ./Bsp/: millisecondtimer.c hardwareserial.cpp Wire.cpp WireBase.cpp interrupt.cpp RingBuffer.cpp
  group Startup
    ./Stm32Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Stm32Libs/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Stm32Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RosLib
    ./RosLibs/: duration.cpp time.cpp STM32Hardware.h
